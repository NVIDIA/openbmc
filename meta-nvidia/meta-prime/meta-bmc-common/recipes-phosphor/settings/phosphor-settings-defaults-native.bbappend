FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://host-template.yaml"
