FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0003-network-link-automatically-reconfigure-interface-on-.patch"

