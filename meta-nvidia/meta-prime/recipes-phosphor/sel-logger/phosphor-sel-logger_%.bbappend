# Enable threshold  monitoring
PACKAGECONFIG:append = " log-threshold log-watchdog"
