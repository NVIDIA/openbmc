# Use NVIDIA gitlab Phosphor Networkd
EXTRA_OEMESON += "-Dstatic-if-list=hmcusb0"
EXTRA_OEMESON += "-Dstatic-if-list=hostusb0"
