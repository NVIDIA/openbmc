FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI = "git://github.com/NVIDIA/dbus-sensors;protocol=https;branch=Core-24.09-1_br"
SRCREV = "d5e2cf2ce851d74dfa817c17ec088715558e73a3"
