FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://ist-config.json \
                 "
