EXTRA_OEMESON:append = " -Dobmc-standby-target="hmc-boot-complete.service" \
                       "

