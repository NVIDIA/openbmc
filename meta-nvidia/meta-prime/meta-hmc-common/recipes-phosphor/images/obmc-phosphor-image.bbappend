OBMC_IMAGE_EXTRA_INSTALL:append = " \
                                    jam-player \
                                  "
