EXTRA_OEMESON += " \
    -Dfirmware-inventory-name=FW_BMC_0\
    -Dplatform-bmc-id=BMC_0 \
"
