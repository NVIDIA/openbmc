FILESEXTRAPATHS:append := "${THISDIR}/config:"

EXTRA_OEMESON:append = " -Derror_cap=100 -Derror_info_cap=10"

