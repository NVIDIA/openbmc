# Assign the OEMDiagnosticDataType for System Dump
EXTRA_OEMESON += "-DSYSTEM_DUMP_OEM_DIAGNOSTIC_ALLOWABLE_TYPE='FPGA,ROT,FirmwareAttributes,HardwareCheckout'"
