OBMC_IMAGE_EXTRA_INSTALL:append = " iputils \
                                    pldm  \
                                    "
OBMC_IMAGE_EXTRA_INSTALL:append = " bmc-systemd-conf \
                                    phosphor-sel-logger \
                                    phosphor-pid-control \
                                    nvidia-tal \
                                    openocd \
                                  "

OBMC_IMAGE_EXTRA_INSTALL:append = " libmctp "

