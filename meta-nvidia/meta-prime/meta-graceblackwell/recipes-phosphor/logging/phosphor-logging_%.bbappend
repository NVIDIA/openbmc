FILESEXTRAPATHS:append := "${THISDIR}/config:"

EXTRA_OEMESON:append = " -Derror_cap=300 -Derror_info_cap=50"

