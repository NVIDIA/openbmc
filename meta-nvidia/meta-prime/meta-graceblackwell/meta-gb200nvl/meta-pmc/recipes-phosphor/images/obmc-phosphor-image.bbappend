OBMC_IMAGE_EXTRA_INSTALL:append = " \ 
                                    nvidia-rack-power-controller \
                                   "
