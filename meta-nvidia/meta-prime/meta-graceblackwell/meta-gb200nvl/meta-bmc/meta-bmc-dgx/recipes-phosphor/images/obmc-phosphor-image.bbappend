OBMC_IMAGE_EXTRA_INSTALL:append = " nvidia-hmc-configurator \
                                  "
