PACKAGECONFIG:append = " secure-boot-database"
