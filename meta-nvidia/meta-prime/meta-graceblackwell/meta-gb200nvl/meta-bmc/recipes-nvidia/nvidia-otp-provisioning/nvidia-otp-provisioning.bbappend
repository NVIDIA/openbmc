FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://otp-bus.sh;sha256sum=a0a1496b3c451a1a4d807077d764992849ea777e7c55159bc7c9781da3d96684 \
	"
