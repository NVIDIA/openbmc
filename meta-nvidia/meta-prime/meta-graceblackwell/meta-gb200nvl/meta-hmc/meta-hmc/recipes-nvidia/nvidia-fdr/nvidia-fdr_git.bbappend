FILESEXTRAPATHS:prepend := "${THISDIR}:"

EXTRA_OEMESON += "-Dplatform_ppf=fdr_ppf_gb200nvl_hmc.yaml"
