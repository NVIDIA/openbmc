EXTRA_OEMESON:append = " -Dsmbus-sysfs-path=/sys/bus/i2c/devices/3-104f/slave-eeprom"
EXTRA_OEMESON:append = " -Dsmbus-telemetry-config-csv=/usr/share/smbus-telemetry-target/smbus-telemetry-config.csv"
