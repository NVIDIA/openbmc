FILESEXTRAPATHS:prepend := "${THISDIR}:"

EXTRA_OEMESON += "-Dplatform_ppf=fdr_ppf_gb200nvl_hmc_1GPU.yaml,fdr_ppf_gb200nvl_hmc_2GPU.yaml"
