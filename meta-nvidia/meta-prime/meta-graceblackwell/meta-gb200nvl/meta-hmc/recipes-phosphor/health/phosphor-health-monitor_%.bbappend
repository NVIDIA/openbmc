FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://process_health_config.json"
