EXTRA_OEMESON += "${@bb.utils.contains('DISTRO_FEATURES', 'mctp-inkernel', ' -Denable-in-kernel-mctp=enabled', '', d)}"