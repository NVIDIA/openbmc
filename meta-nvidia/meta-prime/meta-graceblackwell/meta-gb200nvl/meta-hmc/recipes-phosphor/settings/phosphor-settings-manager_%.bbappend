FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://software_settings.override.yml"

