FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
EXTRA_OECONF = "--without-libnl"
