FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += " file://0001-x509asn1-remove-superfluous-free.patch "
