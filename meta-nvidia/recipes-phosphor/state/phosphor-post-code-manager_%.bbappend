SRC_URI = "git://github.com/NVIDIA/phosphor-post-code-manager;protocol=https;branch=develop"
SRCREV = "257354077d3c77c843702dc920417fc654b392d5"
