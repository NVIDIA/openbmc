SRC_URI = "git://github.com/NVIDIA/phosphor-time-manager;protocol=https;branch=develop"
SRCREV = "26a57dc992aa7fb995d1de423a70a940c999ea54"
DEPENDS += "libmctp"
