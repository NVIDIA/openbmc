FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://debug-token.override.yml \
            file://auto_reboot.override.yml"
