FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI = "git://github.com/NVIDIA/phosphor-net-ipmid;protocol=https;branch=Core-24.09-1_br"
SRCREV = "f33ba5c1a1bacd052d4d97b017aef991326eb418"
