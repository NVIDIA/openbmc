FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += " file://0001-lib-Reject-negative-len-for-XML_ParseBuffer.patch "
