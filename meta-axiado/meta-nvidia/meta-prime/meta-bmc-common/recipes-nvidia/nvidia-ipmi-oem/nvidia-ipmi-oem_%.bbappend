EXTRA_OECMAKE:append:gb200nvl-bmc-axiado = " -Dgb200nvl-oem-commands=1 -Dcpu-diag-enable=1 "
