# Remove nvidia-otp-monitor which is built with Aspeed SoC by default
OBMC_IMAGE_EXTRA_INSTALL:remove = "nvidia-otp-monitor"
