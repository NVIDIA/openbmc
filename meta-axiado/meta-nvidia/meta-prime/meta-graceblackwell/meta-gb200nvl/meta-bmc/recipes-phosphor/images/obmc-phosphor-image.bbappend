# KWS-6053 
OBMC_IMAGE_EXTRA_INSTALL:remove = " nvidia-vmep"
# KWS-7327
OBMC_IMAGE_EXTRA_INSTALL:remove = " nvidia-mac-update"
