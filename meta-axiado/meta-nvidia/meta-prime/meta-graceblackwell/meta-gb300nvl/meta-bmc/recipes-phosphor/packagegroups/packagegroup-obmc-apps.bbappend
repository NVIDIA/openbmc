RDEPENDS:${PN}-extras += "ax-usb \
                          cifs-utils\
                          mmc-utils \
                          pciutils \
                          systemd-analyze \
                          usbutils \
                          phosphor-virtual-sensor \
                          mctp \
                          "
