FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-KWS-6690-use-uint32_t-instead-size_t-to-phosphor-net.patch \
            file://0002-KWS-7706-Adding-channel-specific-privilege.patch \
           "

