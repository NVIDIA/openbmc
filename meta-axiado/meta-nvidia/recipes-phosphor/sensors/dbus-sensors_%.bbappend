CXX += "-Wno-error=stringop-overflow"
