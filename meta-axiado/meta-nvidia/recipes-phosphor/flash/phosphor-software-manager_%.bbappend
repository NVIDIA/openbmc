FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-KWS-7656-enable-factory-reset-feature.patch"
