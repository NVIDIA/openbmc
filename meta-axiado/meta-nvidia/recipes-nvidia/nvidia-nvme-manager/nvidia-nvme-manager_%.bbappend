FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-KWS-6690-use-uint32_t-instead-size_t-to-nvidia-nvme.patch"

